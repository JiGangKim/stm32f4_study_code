<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\09_ADC_Polling_Reading_02.ewp</path>
  </project>
  <batchBuild />
</workspace>
