<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\03_EXTI_Switch_Interrupt_01.ewp</path>
  </project>
  <batchBuild />
</workspace>
