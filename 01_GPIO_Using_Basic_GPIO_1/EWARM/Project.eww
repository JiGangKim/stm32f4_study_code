<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\01_GPIO_Using_Basic_GPIO_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
