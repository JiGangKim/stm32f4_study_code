<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\08_ADC_Polling_Reading_01.ewp</path>
  </project>
  <batchBuild />
</workspace>
