<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\11_ADC_DMA_Reading.ewp</path>
  </project>
  <batchBuild />
</workspace>
