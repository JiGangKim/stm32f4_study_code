<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\15_DAC_DAC_01.ewp</path>
  </project>
  <batchBuild />
</workspace>
