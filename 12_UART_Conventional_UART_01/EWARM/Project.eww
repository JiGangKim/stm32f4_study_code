<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\12_UART_Conventional_UART_01.ewp</path>
  </project>
  <batchBuild />
</workspace>
