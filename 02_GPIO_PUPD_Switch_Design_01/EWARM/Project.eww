<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\02_GPIO_PUPD_Switch_Design_01.ewp</path>
  </project>
  <batchBuild />
</workspace>
