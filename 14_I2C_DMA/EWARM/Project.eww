<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\14_I2C_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
