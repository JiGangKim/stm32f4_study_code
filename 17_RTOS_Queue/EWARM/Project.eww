<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\17_RTOS_Queue.ewp</path>
  </project>
  <batchBuild />
</workspace>
